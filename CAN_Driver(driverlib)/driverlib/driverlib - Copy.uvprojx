# Keil uVision project driverlib - Copy.uvprojx, settings and files
target driverlib (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: driverlib (library)
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk
  c include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: adc.c can.c comp.c cpu.c epi.c ethernet.c flash.c gpio.h gpio.c hibernate.c i2c.h i2c.c i2s.c interrupt.c mpu.c pwm.c qei.c ssi.c sysctl.c systick.c timer.c uart.c udma.c usb.c watchdog.c
    C:/Users/mosta/Downloads/can/can_driver/: can_osama.c simple_tx.c simple_rx.c tm4c123gh6pm.h
    ../inc/: hw_gpio.h hw_i2c.h hw_types.h hw_memmap.h
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
